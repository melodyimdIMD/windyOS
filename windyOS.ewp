# IAR project windyOS.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m2560 ATmega2560
  ICCAVR.CCDefines: IAR_MEGA_AVR
  ICCAVR.newCCIncludePaths: C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\avr\inc\dlib\c; $PROJ_DIR$; src\include; src\kernel\include; src\kernel\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm323.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group Demo
    src/demo/: comtest.c crflash.c heap_1.c integer.c ParTest.c PollQ.c regtest.c serial.c
  group Kernel
    src/kernel/: croutine.c list.c port.c portmacro.s90 queue.c tasks.c test.c
